# Keil uVision project Platform.uvprojx, settings and files
target 32L4R9IDISCOVERY (6160000::V6.16::ARMCLANG)
  device: STM32L4R9AIIx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) XRAM(0x20040000,0x00060000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: image
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: MemoryCard_CD0_Pin_Extern
  c include: .\Board_IO
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT6: RAM 0x2009e000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x9e000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\stm32l4r9.sct
  group App
    ./: Platform.c
  group Board IO
    ./Board_IO/: arduino.c arduino.h mci.c retarget_stdio.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32L4R9AIIx/STCubeGenerated/Src/: main.c stm32l4xx_it.c
    ./RTE/Device/STM32L4R9AIIx/STCubeGenerated/Inc/: stm32l4xx_it.h
  group STM32CubeMX
    ./RTE/Device/STM32L4R9AIIx/STCubeGenerated/: STCubeGenerated.ioc
  group Documentation
    ./: README.md
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3, Board Support:Components:MFXSTM32L152 2.0.4, Board Support:Drivers:Basic I/O 1.1.1, Board Support:Drivers:I/O 1.1.1, Board Support:Drivers:LCD 1.1.1, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, CMSIS Driver:MCI 1.2.0, CMSIS Driver:SPI 1.4.0, CMSIS Driver:USART 1.4.0, CMSIS Driver:VIO:Board 1.0.0, Device:STM32Cube HAL:Common 1.13.0, Device:STM32Cube HAL:Cortex 1.13.0, Device:STM32Cube HAL:DMA 1.13.0, Device:STM32Cube HAL:DMA2D 1.13.0, Device:STM32Cube HAL:DSI 1.13.0, Device:STM32Cube HAL:EXTI 1.13.0, Device:STM32Cube HAL:GFXMMU 1.13.0, Device:STM32Cube HAL:GPIO 1.13.0, Device:STM32Cube HAL:I2C 1.13.0, Device:STM32Cube HAL:IRDA 1.13.0, Device:STM32Cube HAL:LTDC 1.13.0, Device:STM32Cube HAL:MMC 1.13.0, Device:STM32Cube HAL:PWR 1.13.0, Device:STM32Cube HAL:RCC 1.13.0, Device:STM32Cube HAL:SAI 1.13.0, Device:STM32Cube HAL:SD 1.13.0, Device:STM32Cube HAL:SPI 1.13.0, Device:STM32Cube HAL:Smartcard 1.13.0, Device:STM32Cube HAL:UART 1.13.0, Device:STM32Cube HAL:USART 1.13.0, Device:Startup 1.3.1
