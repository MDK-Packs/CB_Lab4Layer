# Keil uVision project Platform.uvprojx, settings and files
target FRDM-K32L3A6 (6160000::V6.16::ARMCLANG)
  device: K32L3A60VPJ1A:cm4 NXP
  pack: NXP.K32L3A60_DFP.13.0.0
  cpu: IRAM(0x48000000,0x1000) IRAM2(0x20000000,0x030000) IROM(0x01000000,0x040000) IROM2(0x00000000,0x100000) XRAM(0x08000000,0x010000) XRAM2(0x09000000,0x020000) XRAM3(0x48010000,0x0800) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: image
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .;.\Board_IO
  memory RVCT4: ROM 0x1000000 size 0x40000
  memory RVCT5: ROM 0x0 size 0x100000
  memory RVCT6: RAM 0x8000000 size 0x10000
  memory RVCT7: RAM 0x48010000 size 0x800
  memory RVCT9: RAM 0x48000000 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: .\RTE\Device\K32L3A60VPJ1A_cm4\K32L3A60xxx_cm4_flash.scf
  group App
    ./: Platform.c
  group Board
    ./: main.c main.h fsl_lpspi_cmsis.c fsl_lpspi_cmsis.h
    ./RTE/Board_Support/: vio_FRDM-K32L3A6.c
  group Board IO
    ./Board_IO/: retarget_stdio.c arduino.c arduino.h
  group MCUXpresso
    ./: FRDM-K32L3A6.mex
  group Documentation
    ./: README.md
software components: CMSIS Driver:SPI:Custom 1.0.0, CMSIS Driver:VIO:Custom 1.0.0, CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Board Support:SDK Project Template:project_template 1.0.0, CMSIS Driver:USART:lpuart_cmsis 2.1.0, Device:CMSIS:K32L3A60_header 1.0.0, Device:CMSIS:K32L3A60_system 1.0.0, Device:SDK Drivers:clock 2.2.1, Device:SDK Drivers:common 2.2.9, Device:SDK Drivers:dmamux 2.0.5, Device:SDK Drivers:edma 2.4.1, Device:SDK Drivers:fxos8700cq 1.0.0, Device:SDK Drivers:gpio 2.5.1, Device:SDK Drivers:i2c 2.2.0, Device:SDK Drivers:lists 1.0.0, Device:SDK Drivers:lpspi 2.1.0, Device:SDK Drivers:lpuart 2.4.1, Device:SDK Drivers:lpuart_adapter 1.0.0, Device:SDK Drivers:msmc 2.1.2, Device:SDK Drivers:port 2.1.1, Device:SDK Project Template:RTE_Device 1.0.0, Device:SDK Utilities:assert 1.0.0, Device:SDK Utilities:debug_console 1.0.0, Device:SDK Utilities:serial_manager 1.0.0, Device:SDK Utilities:serial_manager_uart 1.0.0, Device:Startup 1.1.0
