# Keil uVision project paho_mqtt_demo.uvprojx, settings and files
target LPC54018-IoT-Module (6160000::V6.16::ARMCLANG)
  device: LPC54018JET180 NXP
  pack: NXP.LPC54018_DFP.13.0.0
  cpu: IRAM(0x00000000,0x030000) IRAM2(0x20000000,0x028000) XRAM(0x40100000,0x2000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: image
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .
  asm define: MXL12835F, XIP_IMAGE
  memory RVCT6: RAM 0x40100000 size 0x2000
  memory RVCT9: RAM 0x0 size 0x30000
  memory RVCT10: RAM 0x20000000 size 0x28000
  scatter file: RTE\Device\LPC54018JET180\LPC54018_spifi_flash.scf
  group App
    ./: app_main.c MQTTEcho.c certificates.h socket_startup.c
  group Board
    ./: main.c main.h
  group MCUXpresso
    ./: LPC54018-IoT-Module.mex
  group Documentation
    ./: README.md
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3, Security:mbed TLS 2.24.0, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDOUT 1.2.0, Network:CORE 7.15.0, Network:Interface:WiFi 7.15.0, Network:Service:DNS Client 7.15.0, Network:Socket:BSD 7.15.0, Network:Socket:TCP 7.15.0, Network:Socket:UDP 7.15.0, CMSIS Driver:WiFi:QCA400x 1.2.0, IoT Client:MQTTClient-C 1.1.0, IoT Utility:MQTTPacket 1.1.0, IoT Utility:Socket:MDK Network 1.2.0, Qualcomm:QCA400x:Host Driver SDK 1.0.0, Board Support:SDK Project Template:project_template 1.0.0, CMSIS Driver:SPI:flexcomm_spi_cmsis 2.4.0, Device:CMSIS:LPC54018_header 1.0.0, Device:CMSIS:LPC54018_system 1.0.0, Device:SDK Drivers:clock 2.2.0, Device:SDK Drivers:common 2.2.9, Device:SDK Drivers:dma 2.4.2, Device:SDK Drivers:emc 2.0.4, Device:SDK Drivers:flexcomm 2.0.2, Device:SDK Drivers:gpio 2.1.7, Device:SDK Drivers:inputmux 2.0.3, Device:SDK Drivers:inputmux_connections 2.0.1, Device:SDK Drivers:lists 1.0.0, Device:SDK Drivers:pint 2.1.8, Device:SDK Drivers:power 2.0.0, Device:SDK Drivers:reset 2.0.1, Device:SDK Drivers:spi 2.2.1, Device:SDK Drivers:spi_dma 2.1.1, Device:SDK Drivers:usart 2.4.0, Device:SDK Drivers:usart_adapter 1.0.0, Device:SDK Project Template:RTE_Device 1.0.0, Device:SDK Utilities:debug_console 1.0.0, Device:SDK Utilities:serial_manager 1.0.0, Device:SDK Utilities:serial_manager_uart 1.0.0, Device:Startup:LPC54018_startup 1.1.0
