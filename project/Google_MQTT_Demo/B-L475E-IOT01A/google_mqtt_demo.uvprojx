# Keil uVision project google_mqtt_demo.uvprojx, settings and files
target B-L475E-IOT01A (6140000::V6.14::ARMCLANG)
  device: STM32L475VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: google_mqtt_demo
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\stm32l475.sct
  group Source Code
    ./: app_main.c demo.c pkey.h certificates.h sntp.c socket_startup.c
  group mbedTLS Entropy
    ./RTE/Security/: entropy_hardware_poll.c
  group Documentation
    ./: Abstract.txt
  group STM32CubeMX
    ./RTE/Device/STM32L475VGTx/STCubeGenerated/: STCubeGenerated.ioc
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32L475VGTx/STCubeGenerated/Src/: main.c stm32l4xx_it.c
    ./RTE/Device/STM32L475VGTx/STCubeGenerated/Inc/: stm32l4xx_it.h
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, Security:mbed TLS 2.17.0, Compiler:I/O:STDOUT 1.2.0, CMSIS Driver:SPI 1.2.0, CMSIS Driver:WiFi:ISM43362 1.8.0, Device:STM32Cube HAL:Common 1.11.1, Device:STM32Cube HAL:Cortex 1.11.1, Device:STM32Cube HAL:DMA 1.11.1, Device:STM32Cube HAL:GPIO 1.11.1, Device:STM32Cube HAL:PWR 1.11.1, Device:STM32Cube HAL:RCC 1.11.1, Device:STM32Cube HAL:RNG 1.11.1, Device:STM32Cube HAL:SPI 1.11.1, Device:STM32Cube HAL:UART 1.11.1, Device:Startup 1.3.1, IoT Client:Google 1.0.1, IoT Client:MQTTClient-C 1.1.0, IoT Utility:MQTTPacket 1.1.0, IoT Utility:Socket:WiFi 1.0.0
