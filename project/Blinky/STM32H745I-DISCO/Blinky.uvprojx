# Keil uVision project Blinky.uvprojx, settings and files
target STM32H745I-DISCO (6150000::V6.15::ARMCLANG)
  device: STM32H745XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x38000000,0x00010000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) XRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\RTE\Board_Support;.\RTE\Device\STM32H745XIHx_CM7;.\STM32H745I-DISCO
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT7: RAM 0x2407e000 size 0x2000
  memory RVCT9: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x7e000
  scatter file: .\stm32h745.sct
  group App
    ./: Blinky.c
  group Board
    ./RTE/Device/STM32H745XIHx_CM7/: main.c main.h stm32h7xx_hal_conf.h stm32h7xx_it.c stm32h7xx_it.h
    ./RTE/Board_Support/: vio_STM32H745I-DISCO.c
  group Drivers/BSP/STM32H745I_DISCOVERY
    ./RTE/Board_Support/: stm32h745i_discovery_conf.h
    ./STM32H745I-DISCO/: stm32h745i_discovery.c stm32h745i_discovery.h stm32h745i_discovery_errno.h
  group Documentation
    ./: README.md
software components: CMSIS Driver:VIO:Custom 1.0.0, CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, Compiler:Event Recorder 1.4.0, Device:STM32Cube HAL:Common 1.8.0, Device:STM32Cube HAL:Cortex 1.8.0, Device:STM32Cube HAL:EXTI 1.8.0, Device:STM32Cube HAL:GPIO 1.8.0, Device:STM32Cube HAL:HSEM 1.8.0, Device:STM32Cube HAL:PWR 1.8.0, Device:STM32Cube HAL:RCC 1.8.0, Device:Startup 1.8.0
