# Keil uVision project watson_mqtt_demo.uvprojx, settings and files
target MCB4300 (6150000::V6.15::ARMCLANG)
  device: LPC4357:Cortex-M4 NXP
  pack: Keil.LPC4300_DFP.2.9.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x20000000,0x10000) IROM(0x1A000000,0x80000) IROM2(0x1B000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: image
  AfterMake: $K/ARM/BIN/ElfDwT.exe !L BASEADDRESS(0x1A000000)
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT6: RAM 0x10080000 size 0xa000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\lpc4357.sct
  group App
    ./: app_main.c helloWorld.c socket_startup.c main.c main.h
  group Documentation
    ./: README.md
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, Security:mbed TLS 2.17.0, Compiler:Event Recorder 1.4.0, Compiler:I/O:File 1.2.0, Compiler:I/O:STDOUT 1.2.0, File System:CORE 6.13.8, File System:Drive:Memory Card 6.13.8, Network:CORE 7.14.0, Network:Interface:ETH 7.14.0, Network:Service:DNS Client 7.14.0, Network:Socket:BSD 7.14.0, Network:Socket:TCP 7.14.0, Network:Socket:UDP 7.14.0, CMSIS Driver:Ethernet MAC 2.12, CMSIS Driver:Ethernet PHY:DP83848C 6.2.0, CMSIS Driver:MCI 2.7, Device:SCU 1.1, Device:Startup 1.0.0, Data Exchange:JSON:cJSON 1.7.7, IoT Client:MQTTClient-C 1.1.0, IoT Client:Watson 1.0.1, IoT Utility:MQTTPacket 1.1.0, IoT Utility:Socket:MDK Network 1.2.0
