# Keil uVision project watson_mqtt_demo.uvprojx, settings and files
target MIMXRT1064-EVK ESP8266 (6140000::V6.14::ARMCLANG)
  device: MIMXRT1064DVL6A NXP
  pack: NXP.MIMXRT1064_DFP.12.1.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) IROM(0x70000000,0x400000) XRAM(0x20200000,0x0c0000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: watson_mqtt_demo
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: SKIP_SYSCLK_INIT XIP_BOOT_HEADER_DCD_ENABLE=1 XIP_BOOT_HEADER_ENABLE=1 XIP_EXTERNAL_FLASH=1
  memory RVCT4: ROM 0x70000000 size 0x400000
  memory RVCT6: RAM 0x20200000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\RTE\Device\MIMXRT1064DVL6A\MIMXRT1064xxxxx_flexspi_nor.scf
  link misc: --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group Source Code
    ./: app_main.c helloWorld.c socket_startup.c retarget_stdio.c main.c main.h
  group Documentation
    ./: Abstract.txt
  group MCUXpresso
    ./: MIMXRT1064-EVK.mex
target MIMXRT1064-EVK WizFi360 (6140000::V6.14::ARMCLANG)
  device: MIMXRT1064DVL6A NXP
  pack: NXP.MIMXRT1064_DFP.12.1.0
  cpu: as above
  output: watson_mqtt_demo
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  memory RVCT4: ROM 0x70000000 size 0x400000
  memory RVCT6: RAM 0x20200000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\RTE\Device\MIMXRT1064DVL6A\MIMXRT1064xxxxx_flexspi_nor.scf
  link misc: --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, Security:mbed TLS 2.17.0, Compiler:I/O:File 1.2.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, File System:CORE 6.13.6, File System:Drive:Memory Card 6.13.6, CMSIS Driver:Ethernet MAC 1.0.0, CMSIS Driver:Ethernet PHY:KSZ8081RNA 6.3.0, CMSIS Driver:MCI 1.0.0, CMSIS Driver:WiFi:ESP8266 1.3.0, CMSIS Driver:WiFi:WizFi360 1.4.0, Data Exchange:JSON:cJSON 1.7.7, IoT Client:MQTTClient-C 1.1.0, IoT Client:Watson 1.0.0, IoT Utility:MQTTPacket 1.1.0, IoT Utility:Socket:WiFi 1.0.0, Board Support:SDK Project Template:project_template 1.0.0, CMSIS Driver:USART:lpuart_cmsis_edma 2.0.1, Device:CMSIS:MIMXRT1064_header 1.0.0, Device:SDK Drivers:clock 2.3.2, Device:SDK Drivers:common 2.2.2, Device:SDK Drivers:dmamux 2.0.4, Device:SDK Drivers:edma 2.3.0, Device:SDK Drivers:enet 2.2.5, Device:SDK Drivers:gpio 2.0.3, Device:SDK Drivers:iomuxc 2.0.1, Device:SDK Drivers:lists 1.0.0, Device:SDK Drivers:lpuart 2.2.8, Device:SDK Drivers:lpuart_adapter 1.0.0, Device:SDK Drivers:lpuart_edma 2.2.8, Device:SDK Drivers:sdhc 2.4.0, Device:SDK Drivers:xip_board 2.0.0, Device:SDK Drivers:xip_board_dcd 2.0.0, Device:SDK Drivers:xip_device 2.0.0, Device:SDK Project Template:RTE_Device 1.0.0, Device:SDK Utilities:debug_console 1.0.0, Device:SDK Utilities:serial_manager 1.0.0, Device:SDK Utilities:serial_manager_uart 1.0.0, Device:Startup:MIMXRT1064_startup 1.0.0
