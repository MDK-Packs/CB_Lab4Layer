# Keil uVision project aws_mqtt_demo.uvprojx, settings and files
target Musca-S1 ESP8266 (6140000::V6.14::ARMCLANG)
  device: Musca-S1:CM33-0 ARM
  pack: ARM.Musca-S1_DFP.1.2.0-dev0
  cpu: IRAM(0x00000000,0x00200000) IRAM2(0x0A000000,0x00200000) IROM(0x00200000,0x02000000) IROM2(0x0E000000,0x00000400) XRAM(0x10000000,0x00200000) XRAM2(0x1A000000,0x00200000) XRAM3(0x20000000,0x00080000) XROM(0x10200000,0x02000000) XROM2(0x1E000000,0x00000400) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: aws_mqtt_demo
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RunDemo=RunMqttDemo SECURE_PRIVATE_KEY IOT_MQTT_RESPONSE_WAIT_MS=10000 IOT_NETWORK_MBEDTLS_POLL_TIMEOUT_MS=10000
  memory RVCT1: ROM 0x10200000 size 0x2000000
  memory RVCT2: ROM 0x1e000000 size 0x400
  memory RVCT4: ROM 0x200000 size 0x2000000
  memory RVCT5: ROM 0xe000000 size 0x400
  memory RVCT6: RAM 0x10000000 size 0x200000
  memory RVCT7: RAM 0x1a000000 size 0x200000
  memory RVCT8: RAM 0x20000000 size 0x80000
  memory RVCT9: RAM 0x0 size 0x200000
  memory RVCT10: RAM 0xa000000 size 0x200000
  scatter file: .\RTE\Device\Musca-S1_CM33-0\armcc6_arm.sct
  link misc: --predefine="-I../TFM_SecureFW/RTE/TFM_Platform/Musca-S1_CM33-0/"
  group Source Code
    ./: app_main.c iot_demo.c iot_demo_mqtt.c iot_demo_logging.h socket_startup.c main.c main.h stdout_USART.c
  group Documentation
    ./: Abstract.txt
  group CSME_Lib
    ../TFM_SecureFW/Objects/: tfm_secure_fw_CMSE_Lib.o
target Musca-S1 WizFi360 (6140000::V6.14::ARMCLANG)
  device: Musca-S1:CM33-0 ARM
  pack: ARM.Musca-S1_DFP.1.2.0-dev0
  cpu: as above
  output: aws_mqtt_demo
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  memory RVCT1: ROM 0x10200000 size 0x2000000
  memory RVCT2: ROM 0x1e000000 size 0x400
  memory RVCT4: ROM 0x200000 size 0x2000000
  memory RVCT5: ROM 0xe000000 size 0x400
  memory RVCT6: RAM 0x10000000 size 0x200000
  memory RVCT7: RAM 0x1a000000 size 0x200000
  memory RVCT8: RAM 0x20000000 size 0x80000
  memory RVCT9: RAM 0x0 size 0x200000
  memory RVCT10: RAM 0xa000000 size 0x200000
  scatter file: .\RTE\Device\Musca-S1_CM33-0\armcc6_arm.sct
  link misc: as above
software components: CMSIS Driver:USART 1.1.0, CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, Device:Startup 2.0.0, Security:mbed TLS 2.17.0, TFM:API 1.0.0, Compiler:I/O:STDOUT 1.2.0, CMSIS Driver:WiFi:ESP8266 1.3.0, CMSIS Driver:WiFi:WizFi360 1.4.0, IoT Client:AWS 4.0.0, IoT Utility:AWS:Common 1.1.0, IoT Utility:AWS:MQTT 2.1.0, IoT Utility:AWS:Platform 1.0.0, IoT Utility:Socket:WiFi 1.0.0
