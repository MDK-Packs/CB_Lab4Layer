# Keil uVision project aws_mqtt_demo.uvprojx, settings and files
target STM32F746G-D ESP8266 (6140000::V6.14::ARMCLANG)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.12.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: aws_mqtt_demo
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RunDemo=RunMqttDemo IOT_MQTT_RESPONSE_WAIT_MS=10000 IOT_NETWORK_MBEDTLS_POLL_TIMEOUT_MS=10000
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\aws_mqtt_demo.sct
  group Source Code
    ./: aws_main.c network.c iot_demo.c iot_demo_mqtt.c iot_demo_logging.h
  group mbedTLS Entropy
    ./RTE/Security/: entropy_hardware_poll.c
  group Documentation
    ./: Abstract.txt
  group STM32CubeMX
    ./RTE/Device/STM32F746NGHx/STCubeGenerated/: STCubeGenerated.ioc
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F746NGHx/STCubeGenerated/Src/: main.c stm32f7xx_it.c
    ./RTE/Device/STM32F746NGHx/STCubeGenerated/Inc/: stm32f7xx_it.h
target STM32F746G-D WizFi360 (6140000::V6.14::ARMCLANG)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.12.0
  cpu: as above
  output: aws_mqtt_demo
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\aws_mqtt_demo.sct
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, Security:mbed TLS 2.17.0, Compiler:I/O:STDOUT 1.2.0, CMSIS Driver:USART 1.13.0, CMSIS Driver:WiFi:ESP8266 1.3.0, CMSIS Driver:WiFi:WizFi360 1.4.0, Device:STM32Cube HAL:Common 1.2.7, Device:STM32Cube HAL:Cortex 1.2.7, Device:STM32Cube HAL:DMA 1.2.7, Device:STM32Cube HAL:GPIO 1.2.7, Device:STM32Cube HAL:PWR 1.2.7, Device:STM32Cube HAL:RCC 1.2.7, Device:STM32Cube HAL:RNG 1.2.7, Device:STM32Cube HAL:UART 1.2.7, Device:Startup 1.2.4, IoT Client:AWS 4.0.0, IoT Utility:AWS:Common 1.1.0, IoT Utility:AWS:MQTT 2.1.0, IoT Utility:AWS:Platform 1.0.0, IoT Utility:Socket:WiFi 1.0.0
