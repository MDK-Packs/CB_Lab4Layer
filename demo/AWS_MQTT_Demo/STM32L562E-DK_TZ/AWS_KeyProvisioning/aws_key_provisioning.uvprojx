# Keil uVision project aws_key_provisioning.uvprojx, settings and files
target STM32L562E-DK (6160000::V6.16::ARMCLANG)
  device: STM32L562QEIxQ STMicroelectronics
  pack: Keil.STM32L5xx_DFP.1.3.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x30000000,0x00040000) IROM(0x08000000,0x00080000) IROM2(0x0C000000,0x00080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: aws_key_provisioning
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0xc000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x30000000 size 0x40000
  scatter file: .\RTE\Device\STM32L562QEIxQ\stm32l562xe_flash_ns.sct
  group Source Code
    ./: app_main.c iot_config.h key_provisioning.c
  group Documentation
    ./: README.md
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32L562QEIxQ/STCubeGenerated/Src/: main.c stm32l5xx_it.c
    ./RTE/Device/STM32L562QEIxQ/STCubeGenerated/Inc/: stm32l5xx_it.h
  group CSME_Lib
    ../TFM_SecureFW/Objects/: tfm_secure_fw_CMSE_Lib.o
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, PSA:Crypto:TFM 1.2.0, Security:mbed TLS 2.24.0, TFM:API:Crypto 1.2.0, TFM:Core 1.2.0, Compiler:I/O:STDOUT 1.2.0, Device:STM32Cube HAL:Common 1.0.3, Device:STM32Cube HAL:Cortex 1.0.3, Device:STM32Cube HAL:DMA 1.0.3, Device:STM32Cube HAL:Flash 1.0.3, Device:STM32Cube HAL:GPIO 1.0.3, Device:STM32Cube HAL:ICACHE 1.0.3, Device:STM32Cube HAL:PWR 1.0.3, Device:STM32Cube HAL:RCC 1.0.3, Device:Startup 1.0.3
