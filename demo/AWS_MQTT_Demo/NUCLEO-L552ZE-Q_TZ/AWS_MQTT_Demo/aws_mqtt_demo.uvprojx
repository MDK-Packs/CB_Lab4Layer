# Keil uVision project aws_mqtt_demo.uvprojx, settings and files
target NUCLEO-L552ZE-Q ESP8266 (6160000::V6.16::ARMCLANG)
  device: STM32L552ZETxQ STMicroelectronics
  pack: Keil.STM32L5xx_DFP.1.3.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x30000000,0x00040000) IROM(0x08000000,0x00080000) IROM2(0x0C000000,0x00080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: aws_mqtt_demo
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RunDemo=RunMqttDemo SECURE_PRIVATE_KEY IOT_MQTT_RESPONSE_WAIT_MS=10000 IOT_NETWORK_MBEDTLS_POLL_TIMEOUT_MS=10000
  c include: .\Board_IO
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0xc000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x30000000 size 0x40000
  scatter file: .\RTE\Device\STM32L552ZETxQ\stm32l552xe_flash_ns.sct
  group Source Code
    ./: app_main.c iot_demo.c iot_demo_mqtt.c iot_demo_logging.h socket_startup.c
  group Board IO
    ./Board_IO/: arduino.c arduino.h
  group Documentation
    ./: README.md
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32L552ZETxQ/STCubeGenerated/Src/: main.c stm32l5xx_it.c
    ./RTE/Device/STM32L552ZETxQ/STCubeGenerated/Inc/: stm32l5xx_it.h
  group CMSE_Lib
    ../TFM_SecureFW/Objects/: tfm_secure_fw_CMSE_Lib.o
target NUCLEO-L552ZE-Q WizFi360 (6160000::V6.16::ARMCLANG)
  device: STM32L552ZETxQ STMicroelectronics
  pack: Keil.STM32L5xx_DFP.1.3.0
  cpu: as above
  output: aws_mqtt_demo
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  c include: .\Board_IO
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0xc000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x30000000 size 0x40000
  scatter file: .\RTE\Device\STM32L552ZETxQ\stm32l552xe_flash_ns.sct
target NUCLEO-L552ZE-Q ISM43362 (6160000::V6.16::ARMCLANG)
  device: STM32L552ZETxQ STMicroelectronics
  pack: Keil.STM32L5xx_DFP.1.3.0
  cpu: as above
  output: aws_mqtt_demo
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  c include: .\Board_IO
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0xc000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x30000000 size 0x40000
  scatter file: .\RTE\Device\STM32L552ZETxQ\stm32l552xe_flash_ns.sct
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, PSA:Crypto:TFM 1.2.0, Security:mbed TLS 2.24.0, TFM:API:Crypto 1.2.0, TFM:Core 1.2.0, Compiler:I/O:STDOUT 1.2.0, CMSIS Driver:SPI 1.1.0, CMSIS Driver:USART 1.0.0, CMSIS Driver:WiFi:ESP8266 1.4.0, CMSIS Driver:WiFi:ISM43362 1.9.0, CMSIS Driver:WiFi:WizFi360 1.5.0, Device:STM32Cube HAL:Common 1.0.3, Device:STM32Cube HAL:Cortex 1.0.3, Device:STM32Cube HAL:DMA 1.0.3, Device:STM32Cube HAL:Flash 1.0.3, Device:STM32Cube HAL:GPIO 1.0.3, Device:STM32Cube HAL:ICACHE 1.0.3, Device:STM32Cube HAL:IRDA 1.0.3, Device:STM32Cube HAL:PWR 1.0.3, Device:STM32Cube HAL:RCC 1.0.3, Device:STM32Cube HAL:SPI 1.0.3, Device:STM32Cube HAL:Smartcard 1.0.3, Device:STM32Cube HAL:UART 1.0.3, Device:STM32Cube HAL:USART 1.0.3, Device:Startup 1.0.3, IoT Client:AWS 4.0.0, IoT Utility:AWS:Common 1.1.0, IoT Utility:AWS:MQTT 2.1.0, IoT Utility:AWS:Platform 1.0.0, IoT Utility:Socket:WiFi 1.0.0
